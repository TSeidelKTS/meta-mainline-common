require u-boot-common_2022.07.inc
require u-boot-mainline-tools.inc

inherit python3native
