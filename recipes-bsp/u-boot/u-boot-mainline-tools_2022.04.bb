require u-boot-common_2022.04.inc
require u-boot-mainline-tools.inc
